<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rubik_autosolver.ewp</path>
    </project>
    <batchBuild />
</workspace>
